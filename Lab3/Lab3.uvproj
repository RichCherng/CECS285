# Keil uVision project Lab3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RE2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFFF)  XRAM(0-0x1EFF) CLOCK(60000000) MODP2
  output: Lab3
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 lab3.a51
